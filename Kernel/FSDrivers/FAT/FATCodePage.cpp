// This file is part of PadOS.
//
// Copyright (C) 2026 Kurt Skauen <http://kavionic.com/>
//
// PadOS is free software : you can redistribute it and / or modify
// it under the terms of the GNU General Public License as published by
// the Free Software Foundation, either version 3 of the License, or
// (at your option) any later version.
//
// PadOS is distributed in the hope that it will be useful,
// but WITHOUT ANY WARRANTY; without even the implied warranty of
// MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.See the
// GNU General Public License for more details.
//
// You should have received a copy of the GNU General Public License
// along with PadOS. If not, see <http://www.gnu.org/licenses/>.
///////////////////////////////////////////////////////////////////////////////
// Created: 26/08/27

#include <System/Platform.h>

#include <algorithm>
#include <iterator>
#include <string.h>

#include "FATCodePage.h"

namespace kernel
{

static constexpr uint16_t g_CP437ToUnicode[] =
{
    0x00C7, 0x00FC, 0x00E9, 0x00E2, 0x00E4, 0x00E0, 0x00E5, 0x00E7, 0x00EA, 0x00EB, 0x00E8, 0x00EF, 0x00EE, 0x00EC, 0x00C4, 0x00C5,
    0x00C9, 0x00E6, 0x00C6, 0x00F4, 0x00F6, 0x00F2, 0x00FB, 0x00F9, 0x00FF, 0x00D6, 0x00DC, 0x00A2, 0x00A3, 0x00A5, 0x20A7, 0x0192,
    0x00E1, 0x00ED, 0x00F3, 0x00FA, 0x00F1, 0x00D1, 0x00AA, 0x00BA, 0x00BF, 0x2310, 0x00AC, 0x00BD, 0x00BC, 0x00A1, 0x00AB, 0x00BB,
    0x2591, 0x2592, 0x2593, 0x2502, 0x2524, 0x2561, 0x2562, 0x2556, 0x2555, 0x2563, 0x2551, 0x2557, 0x255D, 0x255C, 0x255B, 0x2510,
    0x2514, 0x2534, 0x252C, 0x251C, 0x2500, 0x253C, 0x255E, 0x255F, 0x255A, 0x2554, 0x2569, 0x2566, 0x2560, 0x2550, 0x256C, 0x2567,
    0x2568, 0x2564, 0x2565, 0x2559, 0x2558, 0x2552, 0x2553, 0x256B, 0x256A, 0x2518, 0x250C, 0x2588, 0x2584, 0x258C, 0x2590, 0x2580,
    0x03B1, 0x00DF, 0x0393, 0x03C0, 0x03A3, 0x03C3, 0x00B5, 0x03C4, 0x03A6, 0x0398, 0x03A9, 0x03B4, 0x221E, 0x03C6, 0x03B5, 0x2229,
    0x2261, 0x00B1, 0x2265, 0x2264, 0x2320, 0x2321, 0x00F7, 0x2248, 0x00B0, 0x2219, 0x00B7, 0x221A, 0x207F, 0x00B2, 0x25A0, 0x00A0,
};

struct UnicodeToCP437Mapping
{
    uint16_t Unicode;
    uint8_t  CP437;

    bool operator<(uint32_t rhs) const
    {
        return Unicode < rhs;
    }
};

static constexpr UnicodeToCP437Mapping g_UnicodeToCP437[] =
{
    {0x00A0, 0xff}, {0x00A1, 0xad}, {0x00A2, 0x9b}, {0x00A3, 0x9c}, {0x00A5, 0x9d}, {0x00AA, 0xa6}, {0x00AB, 0xae}, {0x00AC, 0xaa}, {0x00B0, 0xf8}, {0x00B1, 0xf1}, {0x00B2, 0xfd}, {0x00B5, 0xe6}, {0x00B7, 0xfa}, {0x00BA, 0xa7}, {0x00BB, 0xaf}, {0x00BC, 0xac},
    {0x00BD, 0xab}, {0x00BF, 0xa8}, {0x00C4, 0x8e}, {0x00C5, 0x8f}, {0x00C6, 0x92}, {0x00C7, 0x80}, {0x00C9, 0x90}, {0x00D1, 0xa5}, {0x00D6, 0x99}, {0x00DC, 0x9a}, {0x00DF, 0xe1}, {0x00E0, 0x85}, {0x00E1, 0xa0}, {0x00E2, 0x83}, {0x00E4, 0x84}, {0x00E5, 0x86},
    {0x00E6, 0x91}, {0x00E7, 0x87}, {0x00E8, 0x8a}, {0x00E9, 0x82}, {0x00EA, 0x88}, {0x00EB, 0x89}, {0x00EC, 0x8d}, {0x00ED, 0xa1}, {0x00EE, 0x8c}, {0x00EF, 0x8b}, {0x00F1, 0xa4}, {0x00F2, 0x95}, {0x00F3, 0xa2}, {0x00F4, 0x93}, {0x00F6, 0x94}, {0x00F7, 0xf6},
    {0x00F9, 0x97}, {0x00FA, 0xa3}, {0x00FB, 0x96}, {0x00FC, 0x81}, {0x00FF, 0x98}, {0x0192, 0x9f}, {0x0393, 0xe2}, {0x0398, 0xe9}, {0x03A3, 0xe4}, {0x03A6, 0xe8}, {0x03A9, 0xea}, {0x03B1, 0xe0}, {0x03B4, 0xeb}, {0x03B5, 0xee}, {0x03C0, 0xe3}, {0x03C3, 0xe5},
    {0x03C4, 0xe7}, {0x03C6, 0xed}, {0x207F, 0xfc}, {0x20A7, 0x9e}, {0x2219, 0xf9}, {0x221A, 0xfb}, {0x221E, 0xec}, {0x2229, 0xef}, {0x2248, 0xf7}, {0x2261, 0xf0}, {0x2264, 0xf3}, {0x2265, 0xf2}, {0x2310, 0xa9}, {0x2320, 0xf4}, {0x2321, 0xf5}, {0x2500, 0xc4},
    {0x2502, 0xb3}, {0x250C, 0xda}, {0x2510, 0xbf}, {0x2514, 0xc0}, {0x2518, 0xd9}, {0x251C, 0xc3}, {0x2524, 0xb4}, {0x252C, 0xc2}, {0x2534, 0xc1}, {0x253C, 0xc5}, {0x2550, 0xcd}, {0x2551, 0xba}, {0x2552, 0xd5}, {0x2553, 0xd6}, {0x2554, 0xc9}, {0x2555, 0xb8},
    {0x2556, 0xb7}, {0x2557, 0xbb}, {0x2558, 0xd4}, {0x2559, 0xd3}, {0x255A, 0xc8}, {0x255B, 0xbe}, {0x255C, 0xbd}, {0x255D, 0xbc}, {0x255E, 0xc6}, {0x255F, 0xc7}, {0x2560, 0xcc}, {0x2561, 0xb5}, {0x2562, 0xb6}, {0x2563, 0xb9}, {0x2564, 0xd1}, {0x2565, 0xd2},
    {0x2566, 0xcb}, {0x2567, 0xcf}, {0x2568, 0xd0}, {0x2569, 0xca}, {0x256A, 0xd8}, {0x256B, 0xd7}, {0x256C, 0xce}, {0x2580, 0xdf}, {0x2584, 0xdc}, {0x2588, 0xdb}, {0x258C, 0xdd}, {0x2590, 0xde}, {0x2591, 0xb0}, {0x2592, 0xb1}, {0x2593, 0xb2}, {0x25A0, 0xfe}
};

static constexpr char g_CP437LowercaseCharacters[] = "\x81\x82\x84\x86\x87\x91\x94\xA4\xE5\xED";
static constexpr char g_CP437UppercaseCharacters[] = "\x9A\x90\x8E\x8F\x80\x92\x99\xA5\xE4\xE8";
static_assert(sizeof(g_CP437LowercaseCharacters) == sizeof(g_CP437UppercaseCharacters));

///////////////////////////////////////////////////////////////////////////////
/// \author Kurt Skauen
///////////////////////////////////////////////////////////////////////////////

uint32_t CP437ToUnicode(uint8_t character)
{
    if (character < 0x80) {
        return character;
    } else {
        return g_CP437ToUnicode[character - 0x80];
    }
}

///////////////////////////////////////////////////////////////////////////////
/// \author Kurt Skauen
///////////////////////////////////////////////////////////////////////////////

bool UnicodeToCP437(uint32_t unicode, uint8_t* result)
{
    if (unicode < 0x80)
    {
        *result = uint8_t(unicode);
        return true;
    }

    const auto mapping = std::lower_bound(std::begin(g_UnicodeToCP437), std::end(g_UnicodeToCP437), unicode);
    if (mapping == std::end(g_UnicodeToCP437) || mapping->Unicode != unicode) {
        return false;
    }

    *result = mapping->CP437;
    return true;
}

///////////////////////////////////////////////////////////////////////////////
/// \author Kurt Skauen
///////////////////////////////////////////////////////////////////////////////

static uint8_t MapCP437Character(uint8_t character, const char* sourceCharacters, const char* destinationCharacters)
{
    const char* sourceCharacter = strchr(sourceCharacters, character);
    if (sourceCharacter != nullptr)
    {
        const size_t mappingIndex = size_t(sourceCharacter - sourceCharacters);
        return uint8_t(destinationCharacters[mappingIndex]);
    }
    return character;
}

///////////////////////////////////////////////////////////////////////////////
/// \author Kurt Skauen
///////////////////////////////////////////////////////////////////////////////

uint8_t CP437CharacterToLower(uint8_t character)
{
    if (character >= 'A' && character <= 'Z') {
        return uint8_t(character - 'A' + 'a');
    }
    return MapCP437Character(character, g_CP437UppercaseCharacters, g_CP437LowercaseCharacters);
}

///////////////////////////////////////////////////////////////////////////////
/// \author Kurt Skauen
///////////////////////////////////////////////////////////////////////////////

uint8_t CP437CharacterToUpper(uint8_t character)
{
    if (character >= 'a' && character <= 'z') {
        return uint8_t(character - 'a' + 'A');
    }
    return MapCP437Character(character, g_CP437LowercaseCharacters, g_CP437UppercaseCharacters);
}

} // namespace kernel

